# IAR project t_mmc.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR711 ST STR711
  ICCARM.CCDefines: LITTLE_ENDIAN=1
  ICCARM.CCIncludePath2: ..\include\; 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: t_mmc.srec
  ILINK.IlinkOutputFile: t_mmc.out
  ILINK.IlinkIcfFile: ..\linker\STR71x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 71x_it.c fat.c main.c partition.c sd_raw.c
    ../source/: bspi.c
  group source
    $EW_DIR$/arm/examples/ST/STR71x/STR71xLibrary/source/: 71x_lib.c gpio.c rccu.c uart.c
  group startup
    $EW_DIR$/arm/examples/ST/STR71x/STR71xLibrary/startup/: 71x_init.s 71x_vect.s
